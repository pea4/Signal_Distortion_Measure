# Keil uVision project ADC1_DMA_TIM1Trig.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SPL_Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10xxx
  c include: ..\Lib\CMSIS\CM3\CoreSupport;..\User;..\Lib\STM32F10x_StdPeriph_Driver\inc;..\Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\User\USART;..\User\delay;..\User\sys;..\User\adc1;..\Lib\DSP_Library\Inc;..\Lib\DSP_Library
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group User
    ../User/: main.c stm32f10x_it.c
    ../User/USART/: USART1.c
    ../User/delay/: delay.c
    ../User/sys/: sys.c
    ../User/adc1/: adc1.c
  group STM32F1xx_StdPeriph_Driver
    ../Lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group DSP_LIB
    ../Lib/DSP_Library/: cr4_fft_256_stm32.s cr4_fft_1024_stm32.s stm32_dsp.h table_fft.h
    ../Lib/DSP_Library/Src/: fft_calculate.c
